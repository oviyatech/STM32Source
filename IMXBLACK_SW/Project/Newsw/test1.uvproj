# Keil uVision project test1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F417ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: test1 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\Obj;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Newsw;..\..\Utilities\Camera;..\..\Utilities\SramNAND\Nand_MT29F1G08;..\..\Utilities\SramNAND\STM3240_41_G_EVAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Default
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group User codes
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./: main.c stm32f4xx_it.c
  group Other Libraries
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Camera
    ../../Utilities/Camera/: camera_api.c dcmi_ov2640.c camera_api.h dcmi_ov2640.h lcd_log_conf.h Serial_receive.c Serial_receive.h
  group SramNAND
    ../../Utilities/SramNAND/Nand_MT29F1G08/: Fsmc_Nand.c Fsmc_Nand.h
    ../../Utilities/SramNAND/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval.h stm324xg_eval_fsmc_sram.c stm324xg_eval_fsmc_sram.h
